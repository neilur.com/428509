Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2023-02-27T18:26:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 27 18:26:08 2023 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\76429d96-8907-4a7c-9747-87c9216e957b\69a6b81b-7920-4da5-8813-f84817c10ea9\ifc * Database version: 5507 * Database creation date: Mon Feb 27 18:26:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 27 18:26:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 27 18:26:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
In: n/a
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcDistributionPort (3)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_439921
Port_439935
Port_439946

# IfcFlowTerminal: DBLTD_Duten_ShowerTrayWastes_A864:Reversible Center Waste Brushed Brass, 6
In: Level 0
Type - PredefinedType: WASTETRAP; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Duten_Metal_BrushedBrass
Pset_DistributionFlowElementCommon - Reference: Reversible Center Waste Brushed Brass; sets with these values: 2
Pset_ElementShading - Color: Silver, Black or Brass
Pset_ManufacturerTypeInformation - ModelReference: Reversible Center Waste Brushed Brass; Manufacturer: Duten
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: DBLTD_Duten_ShowerTrayWastes_A864:Reversible Center Waste Brushed Stainless Steel, 7
In: Level 0
Type - PredefinedType: WASTETRAP; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Duten_Metal_BrushedStainlessSteel
Pset_DistributionFlowElementCommon - Reference: Reversible Center Waste Brushed Stainless Steel; sets with these values: 2
Pset_ElementShading - Color: Silver, Black or Brass
Pset_ManufacturerTypeInformation - ModelReference: Reversible Center Waste Brushed Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: DBLTD_Duten_ShowerTrayWastes_A864:Reversible Center Waste Matte Black, 8
In: Level 0
Type - PredefinedType: WASTETRAP; Classification: D2010710 Showers (Uniformat); Material: DBLTD_Duten_Metal_MatteBlack
Pset_DistributionFlowElementCommon - Reference: Reversible Center Waste Matte Black; sets with these values: 2
Pset_ElementShading - Color: Silver, Black or Brass
Pset_ManufacturerTypeInformation - ModelReference: Reversible Center Waste Matte Black; Manufacturer: Duten
Pset_ProductRequirements - Category: Plumbing Fixtures
